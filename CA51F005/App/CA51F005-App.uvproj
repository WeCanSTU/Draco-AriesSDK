# Keil uVision project CA51F005-App.uvproj, settings and files
target App (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: CA51F005-App +hex
  AfterMake: hex2bin.exe #L.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG
  c include: .\User;..\..\Sdk\AriesSDK;..\..\Sdk\CA51F005\应用实例\I2C_Master_Slave\I2C_Master;..\..\Sdk\CA51F005\应用实例\Flash_Data_Area_Access
  link misc: REMOVEUNUSED
  group Application/User
    ./User/: main.c
    ../../Sdk/CA51F005/应用实例/I2C_Master_Slave/I2C_Master/source/: system_clock.c delay.c
  group Lib
    ./User/: STARTUP.A51
  group AriesSDK
    ../../Sdk/AriesSDK/Keil-8051/: AriesSDK-CDC.lib
  group Port
    ../Port/: user_i2c_drv.c
